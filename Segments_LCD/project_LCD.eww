<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\blink\blink.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\button\button.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\project_LCD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


