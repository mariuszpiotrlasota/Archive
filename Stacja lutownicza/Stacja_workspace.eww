<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\Stacja_v10\_v1.0.ewp</path>
  </project>
  <batchBuild/>
</workspace>


